<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Receiver\Receiver_prj.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Transceiver\Transceiver_prj.ewp</path>
  </project>
  <batchBuild/>
</workspace>


